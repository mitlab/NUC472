# Keil uVision project UART_TxRx_Function.uvproj, settings and files
target UART (ARM-ADS)
  device: NUC472KI8AE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: Simple_Test
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/CMSIS/Include/: core_cm4.h
    ../../../../Library/Device/Nuvoton/NUC472_442/Include/: NUC472_442.h system_NUC472_442.h
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group User
    ../: system.c buffer.c cmd.c main.c board.c time_api.c gpio_api.c packet.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c clk.c retarget.c uart.c rtc.c gpio.c adc.c
