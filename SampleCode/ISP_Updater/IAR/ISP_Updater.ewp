# IAR project ISP_Updater.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\Device\Nuvoton\NUC472_442\Include; ..\..\..\Library\CMSIS\Include; ..\..\..\Library\StdDriver\inc; ..\..\..\ThirdParty\FATFS\src; ..\..\..\Library\UsbHostLib\SOURCE\lw_hcd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ISP_Updater.bin
  ILINK.IlinkOutputFile: ISP_Updater.out
  ILINK.IlinkIcfFile: ISP_Updater.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
    ../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group Library
    ../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c
    ../../../ThirdParty/FATFS/src/: ff.c
  group LW_HCD Files
    ../../../Library/UsbHostLib/SOURCE/LW_HCD/: lw_umass.c lw_usbh.c
  group User
    ../: diskio.c main.c
