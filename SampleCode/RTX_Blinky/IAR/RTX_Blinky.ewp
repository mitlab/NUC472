# IAR project RTX_Blinky.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\Library\CMSIS\Include; ..\..\..\Library\CMSIS\RTOS\RTX\INC; ..\..\..\Library\Device\Nuvoton\NUC472_442\Include; $PROJ_DIR$..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTX_Blinky.bin
  ILINK.IlinkOutputFile: RTX_Blinky.out
  ILINK.IlinkIcfFile: RTX_Blinky.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Documentation
    ../: Abstract.txt
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group RTX Configuration
    ../../../Library/CMSIS/RTOS/RTX/LIB/IAR/: RTX_CM4.a
    ../: RTX_Conf_CM.c
  group StartUp
    ../../../Library/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
    ../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group User
    ../: Blinky.c LED.c
